<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\opgave10\opgave10.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\opgave9\opgave9.ewp</path>
    </project>
    <batchBuild />
</workspace>
